FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://vcan.cfg"
